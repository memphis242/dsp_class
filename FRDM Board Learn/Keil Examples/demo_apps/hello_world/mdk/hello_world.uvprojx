# Keil uVision project hello_world.uvprojx, settings and files
target hello_world debug (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK22FN512VLH12, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K22F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ./: hello_world.c
  group doc
    ./: readme.txt
target hello_world release (ARM-ADS)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK22FN512VLH12, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K22F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: .;
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MK22F51212_header 1.0.0, Device:SDK Drivers:clock 2.3.0, Device:SDK Drivers:common 2.2.4, Device:SDK Drivers:gpio 2.5.1, Device:SDK Drivers:i2c 2.0.8, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.3.0, Device:SDK Drivers:port 2.1.0, Device:SDK Drivers:rtc 2.2.1, Device:SDK Drivers:smc 2.0.7, Device:SDK Drivers:uart 2.3.0, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MK22F51212_startup 1.1.0
