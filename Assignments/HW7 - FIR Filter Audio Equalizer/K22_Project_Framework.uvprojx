# Keil uVision project K22_Project_Framework.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.2.3.0
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: K22_Project_Framework
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: ADC.c DAC.c MCG.c TimerInt.c ADC.h DAC.h MCG.h TimerInt.h PORT.h useful_func.h useful_func.c main.c PORT.c coeffH.h BUTTONS.h BUTTONS.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 1.0.0
